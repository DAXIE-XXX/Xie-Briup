# Keil uVision project N1T08.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: N1T08
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: agreement.c function.c main.c
  group Boot
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group Devices
    ../Devices/: devices_beep.c devices_bh1750.c devices_co2.c devices_environment.c devices_fan.c devices_lock.c devices_pm2_5.c devices_pt4115.c devices_relay.c devices_rgb_led.c devices_security.c devices_servo.c devices_sht20.c devices_software_iic.c devices_step_motor.c devices_usart01_debug.c devices_usart02_zigbee.c devices_usart03_device.c devices_veml6070.c devices_ws2812b.c figure_print.c JXL12864G-086.c rc522.c
  group Libraries
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group System
    ../System/: system_delay.c system_option.c
software components: CMSIS:CORE 5.6.0
